# Keil uVision project main.uvproj, settings and files
target Target 1 (MCS-51)
  device: STC15F2K60S2 STC
  cpu: IRAM(0-0xFF) XRAM(0-0x6FF) IROM(0-0xEFF8) CLOCK(35000000) MODP2
  output: motor +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: ..\INC
  asm include: ..\INC
  group main
    ./MAIN/: main.c STARTUP.A51
  group INIT
    ./INIT/: init.c
  group INTERRUPT
    ./INTERRUPT/: interrupt.c
  group APP
    ./APP/: motorctrl.c AngleCalc.c uart.c
